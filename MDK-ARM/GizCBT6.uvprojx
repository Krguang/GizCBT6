# Keil uVision project GizCBT6.uvprojx, settings and files
target GizCBT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GizCBT6
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Gizwits; ..\Hal; ..\Utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_uart.c stm32f1xx_hal_pwr.c
  group Application/User
    ../Src/: usart.c stm32f1xx_it.c gpio.c tim.c main.c stm32f1xx_hal_msp.c
software components: CMSIS:CORE 4.3.0
